Commit message: fix point cmd

File: src/angle_arm/angle_arm_model_gazebo/urdf/angle_arm.urdf (robot description, URDF)
Before this commit: robot angle_robot, 9 links, 8 joints
Joints:
- joint ang_joint1: origin xyz=0 0 0.107 rpy=1.57 0 -1.57 -> xyz=0 0 0.117 rpy=1.57 0 -1.57
